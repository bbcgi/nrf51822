# Keil uVision project ble_app_hids_keyboard.uvproj, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_hids_keyboard +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_PCA10028 S110  __NUS__
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\device_manager;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s110;..\..\..\..\..\Include\sd_common;..\..\..\..\..\Include\sdk;..\..\..\..\..\..\..\..\CMSIS\Include;..\Include
  memory RVCT4: ROM 0x16000 size 0x29000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Startup Code
    ./../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ./../../../../../Source/templates/: system_nrf51.c
  group Uses
    ../: main.c
    ../../../../../Source/nrf_delay/: nrf_delay.c
    ../../../../../Source/nrf_nvmc/: nrf_nvmc.c
  group Libraries
    ../../../../../Source/ble/ble_services/: ble_bas.c ble_dis.c ble_hids.c ble_srv_common.c
    ../../../../../Source/ble/: ble_advdata.c ble_error_log.c ble_conn_params.c
    ../../../../../Source/app_common/: app_scheduler.c app_timer.c pstorage.c crc16.c app_button.c app_gpiote.c
    ../../../../../Source/sd_common/: softdevice_handler.c
    ../../../../../Source/ble/device_manager/: device_manager_peripheral.c
  group MYBLEPERI
    ../myBLEPERIPHERAL/: ble_nus.c HidoverGATT_Config.c myUART_HID.c
  group utility
    ../utility/: myUTILITY.c ackMATH.c sha256.c
  group peripheral
    ../peripheral/: peripheral.c
  group myFSM
    ../myFSM/: readSTATE.c writeSTATE.c eraseSTATE.c dynamicKBSTATE.c cmdParser.c
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: as above
  output: ble_app_hids_keyboard +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_NRF6310
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\device_manager;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s110;..\..\..\..\..\Include\sd_common;..\..\..\..\..\Include\sdk
  memory RVCT4: ROM 0x16000 size 0x9000
  memory RVCT9: RAM 0x20002000 size 0x2000
